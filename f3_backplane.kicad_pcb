# Repository dritory/f3_backplane

## KiCad design f3_backplane.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.5mm_Pad_Via_With_Alignment_Hole

Connections:
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

Notes on the sheet:
F3 Backplane
Mounting Holes

Parts:
C1, C2: 47uF; C_0805_2012Metric
C3: 22uF; C_0805_2012Metric
C4, C5: 100nF; C_0603_1608Metric
J2: Bus_M.2_Socket_M; Amphenol_MDT420M01001; Digikey Part No. MDT420M01001CT-ND

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, C5.1, J2.2 (3.3V), J2.4 (3.3V), J2.12 (3.3V), J2.14 (3.3V), J2.16 (3.3V), J2.18 (3.3V), J2.70 (3.3V), J2.72 (3.3V), J2.74 (3.3V); also elsewhere on the board
/PCIE_REFCLK+: J2.55 (REFCLKp); also elsewhere on the board
/PCIE_REFCLK-: J2.53 (REFCLKn); also elsewhere on the board
/PCIE_RX+: J2.43 (PERp0/SATA-B-); also elsewhere on the board
/PCIE_RX-: J2.41 (PERn0/SATA-B+); also elsewhere on the board
/PCIE_TX+: J2.49 (PETp0/SATA-A+); also elsewhere on the board
/PCIE_TX-: J2.47 (PETn0/SATA-A-); also elsewhere on the board
/PERST#: J2.50 (~PERST); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J2.1 (GND), J2.3 (GND), J2.9 (GND), J2.15 (GND), J2.21 (GND), J2.27 (GND), J2.33 (GND), J2.39 (GND), J2.45 (GND), J2.51 (GND), J2.57 (GND), J2.71 (GND), J2.73 (GND), J2.75 (GND); also elsewhere on the board

Notes on the sheet:
M.2 SSD M-Key connector

Parts:
J1: PCIEx4_HOST

Connections:
+3.3V: J1.A13 (3.3V), J1.A14 (3.3V), J1.B12 (3.3V); also elsewhere on the board
+5V: J1.A8 (5V), J1.A9 (5V), J1.A10 (5V), J1.B8 (5V), J1.B9 (5V); also elsewhere on the board
+12V: J1.A2 (12V), J1.A3 (12V), J1.B1 (12V), J1.B2 (12V), J1.B3 (12V); also elsewhere on the board
/Connector/B30: J1.B30
/Connector/B31: J1.B31
/PCIE_REFCLK+: J1.B23 (PE1_REFCLK+); also elsewhere on the board
/PCIE_REFCLK-: J1.B24 (PE1_REFCLK-); also elsewhere on the board
/PCIE_RX+: J1.A21 (PE1_RX+); also elsewhere on the board
/PCIE_RX-: J1.A22 (PE1_RX-); also elsewhere on the board
/PCIE_TX+: J1.B19 (PE1_TX+); also elsewhere on the board
/PCIE_TX-: J1.B20 (PE1_TX-); also elsewhere on the board
/PERST#: J1.B17 (PERST); also elsewhere on the board
/SATA1_A+: J1.B5 (SATA1_A+); also elsewhere on the board
/SATA1_A-: J1.B6 (SATA1_A-); also elsewhere on the board
/SATA1_B+: J1.A5 (SATA1_B+); also elsewhere on the board
/SATA1_B-: J1.A6 (SATA1_B-); also elsewhere on the board
/SATA2_A+: J1.B14 (SATA2_A+); also elsewhere on the board
/SATA2_A-: J1.B15 (SATA2_A-); also elsewhere on the board
/SATA2_B+: J1.A16 (SATA2_B+); also elsewhere on the board
/SATA2_B-: J1.A17 (SATA2_B-); also elsewhere on the board
GND: J1.A4 (GND), J1.A12 (GND), J1.A15 (GND), J1.A18 (GND), J1.A20 (GND), J1.A23 (GND), J1.A24 (GND), J1.A27 (GND), J1.A28 (GND), J1.A31 (GND), J1.B4 (GND), J1.B7 (GND), J1.B13 (GND), J1.B16 (GND), J1.B18 (GND), J1.B21 (GND), J1.B22 (GND), J1.B25 (GND), J1.B26 (GND), J1.B29 (GND), J1.B32 (GND); also elsewhere on the board

Notes on the sheet:
The Terramaster F2 motherboard has a PCIe x4 connector with non-standard pinout. It provides 12V, 5V and 3.3V power rails, 2xSATA and 2xPCIe (gen 2) 1-lane. The purpose of pins A1, A11, A32, B10, B11, B30 and B31 are unknown to me but leaving them unconnected result in a working backplane. ¯\_(ツ)_/¯

Parts:
C10, C16: 10uF; C_0805_2012Metric
C11, C14, C15, C17, C20, C21, C43, C45: 100nF; C_0603_1608Metric
C12, C13, C18, C19: 22uF; C_0805_2012Metric
J3: SATA_Backplane; Molex_0877011001; Digikey Part No. WM3587-ND
R1, R2: 2R2; R_2512_6332Metric
U1: STEF512; TSOT23-8L

Connections:
+5V: C10.1, C11.1, U1.4 (Vin_5); also elsewhere on the board
+12V: C16.1, C17.1, U1.1 (Vin_12); also elsewhere on the board
/SATA1/PRESENT#: J3.P4 (PRESENT#), U1.7 (!EN)
/SATA1/SATA_PRE_5V: J3.P7 (5V_PRE), R2.2
/SATA1/SATA_PRE_12V: J3.P13 (12V_PRE), R1.2
/SATA1_A+: J3.S2 (SATA_A+); also elsewhere on the board
/SATA1_A-: J3.S3 (SATA_A-); also elsewhere on the board
/SATA1_B+: J3.S6 (SATA_B+); also elsewhere on the board
/SATA1_B-: J3.S5 (SATA_B-); also elsewhere on the board
GND: C10.2, C11.2, C12.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C43.2, C45.2, J3.P5 (GND), J3.P6 (GND), J3.P10 (GND), J3.P12 (GND), J3.S1 (GND), J3.S4 (GND), J3.S7 (GND), U1.6 (GND); also elsewhere on the board
unnamed: C45.1, U1.3 (SS_5)
unnamed: C43.1, U1.2 (SS_12)

Parts of its further copies:
C30, C36: 10uF; C_0805_2012Metric
C31, C34, C35, C37, C40, C41, C44, C46: 100nF; C_0603_1608Metric
C32, C33, C38, C39: 22uF; C_0805_2012Metric
J4: SATA_Backplane; Molex_0877011001; Digikey Part No. WM3587-ND
R3, R4: 2R2; R_2512_6332Metric
U3: STEF512; TSOT23-8L

Connections of its further copies:
+5V: C30.1, C31.1, U3.4 (Vin_5); also elsewhere on the board
+12V: C36.1, C37.1, U3.1 (Vin_12); also elsewhere on the board
/SATA2/PRESENT#: J4.P4 (PRESENT#), U3.7 (!EN)
/SATA2/SATA_PRE_5V: J4.P7 (5V_PRE), R4.2
/SATA2/SATA_PRE_12V: J4.P13 (12V_PRE), R3.2
/SATA2_A+: J4.S2 (SATA_A+); also elsewhere on the board
/SATA2_A-: J4.S3 (SATA_A-); also elsewhere on the board
/SATA2_B+: J4.S6 (SATA_B+); also elsewhere on the board
/SATA2_B-: J4.S5 (SATA_B-); also elsewhere on the board
GND: C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C44.2, C46.2, J4.P5 (GND), J4.P6 (GND), J4.P10 (GND), J4.P12 (GND), J4.S1 (GND), J4.S4 (GND), J4.S7 (GND), U3.6 (GND); also elsewhere on the board
unnamed: C46.1, U3.3 (SS_5)
unnamed: C44.1, U3.2 (SS_12)

Notes on the sheet:
The power circuit I reverse engineered on the existing backplane PCB ended up being a discreet load switch for each power rail (5V and 12V, per drive) with a slow starter. Pin P4 on the SATA connector is used as a detect pin as it's shorted to ground when a drive is connected, enabling the load swi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
SATA connector with power circuitry

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
Board: 4 copper layers, 95.8 x 82.4 mm, 44 parts (33 on the bottom side), 33 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"_8, _7, _6, _5, _4, _3, _2, ",,8,,
"C1, C2",0805,2,47uF,
"C10, C16, C30, C36",0805,4,10uF,
"C11, C15, C17, C20, C31, C34, C35, C37, C4, C40, C41, C43, C44, C45, C46, C5",0603,16,100nF,
"C12, C18, C19, C3, C32, C33, C38, C39",0805,8,22uF,
J2,Amphenol_MDT420M01001,1,Bus_M.2_Socket_M,
"J3, J4",Molex_0877011001,2,SATA_Backplane,
"R1, R2, R3, R4",2512,4,2R2,
"U1, U3",TSOT23-8L,2,STEF512,

## Commit log

2025-05-25 no DRC errors
2025-09-26 revision V1.1
